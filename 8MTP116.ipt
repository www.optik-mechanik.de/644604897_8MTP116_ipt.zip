# Autodesk Inventor part: 8TP116
## iProperties
Created: 2008-10
Part Number: 8TP116
Document SubType Name: Modeling
Designer: Darius
Author: Darius
